FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://001-ethwan-interfaceupdatefor5eth.patch \
	    file://002_EthAgent_lnkspeed_redn_fndecl.patch \
	     "
