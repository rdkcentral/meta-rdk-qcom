require ccsp_common_ipq.inc
