require ccsp_common_ipq.inc

CFLAGS_append = "-D_COSA_QCA_ARM_"
