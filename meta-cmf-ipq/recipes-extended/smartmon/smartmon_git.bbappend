SRC_URI = "${CMF_GITHUB_ROOT}/smartmon;protocol=${CMF_GIT_PROTOCOL};branch=main"
