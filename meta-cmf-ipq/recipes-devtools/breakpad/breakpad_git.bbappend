FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append = " file://breakpad_cstdint_gcc13.patch "
