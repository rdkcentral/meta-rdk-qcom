SRC_URI_remove = "${CMF_GITHUB_ROOT}/rtRemote;protocol=${CMF_GIT_PROTOCOL};branch=${CMF_GITHUB_RELEASE_BRANCH}"
SRC_URI += "${CMF_GITHUB_ROOT}/rtRemote;protocol=${CMF_GIT_PROTOCOL};branch=release"
