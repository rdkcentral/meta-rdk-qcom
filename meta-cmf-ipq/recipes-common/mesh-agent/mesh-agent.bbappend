CFLAGS += " -DWAN_FAILOVER_SUPPORTED "
