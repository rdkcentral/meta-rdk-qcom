
FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI += " \
	    file://01-fix-compile-errors.patch \
	    "
