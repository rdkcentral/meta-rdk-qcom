FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI += " \
            file://0014-omapilibs.patch \
            "
