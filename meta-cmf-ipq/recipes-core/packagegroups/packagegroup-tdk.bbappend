RDEPENDS_packagegroup-tdk_remove= "\
  tdksm \
"
