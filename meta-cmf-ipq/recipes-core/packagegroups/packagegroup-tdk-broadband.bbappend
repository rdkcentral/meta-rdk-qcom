#RDEPENDS_packagegroup-tdk-broadband_remove= "tdk-b"
