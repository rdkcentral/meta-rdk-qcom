RDEPENDS_packagegroup-rdk-baserootfs_remove_ipq += "\
    tr69agent \
    tr69hostif \
"
